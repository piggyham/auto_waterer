# Keil uVision project auto_dwater(2).uvprojx, settings and files
target auto_dwater (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: auto_water +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Test/: LCD_test.c key_test.c TIM3_test.c ADC_test.c menu_test.c buzzer_test.c motor_test.c dht11_test.c RTC_test.c RTC_alarm_test.c flash_test.c battery_test.c pwr_test.c dwater_logic_test.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/ST7735/: st7735.c
    ../../Drivers/BSP/LINKLIST/: linklist.c
    ../../Drivers/BSP/MENU/: menu.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/BEER/: beer.c
    ../../Drivers/BSP/MOTER/: moter.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/PWR/: pwr.c
    ../../Drivers/BSP/FLASH/: flash.c
    ../../Drivers/BSP/GTIM/: gtim.c
    ../../Drivers/BSP/DWATER/: dwater.c
    ../../Drivers/BSP/BATTERY/: battery.c
  group Readme
    ../../: readme.txt
  group Middlewares
    ../../Middlewares/MALLOC/: malloc.c
